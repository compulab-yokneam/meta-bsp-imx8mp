COMPATIBLE_MACHINE = "${MACHINE}"
