linux-compulab-rt-cfg.inc