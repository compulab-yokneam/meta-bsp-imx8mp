PACKAGECONFIG:append = " modemmanager ppp "
RCONFLICTS:${PN}:remove = "connman"
