SRCBRANCH = "linux-compulab_v6.6.52"
SRCREV = "b78b36c033a5095df9c46b119dfbec5a1e9033ad"
