SRCBRANCH = "u-boot-compulab_v2023.04"
SRCREV = "facddf8faa629f07cffb2dae8b92d6f6a96e9583"
