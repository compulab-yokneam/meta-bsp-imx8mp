SRC_URI = "git://github.com/cracklib/cracklib;protocol=https;branch=main"
SRCREV = "81f9ef98ecb90dc295ec2c59d44b2a7ba9335376"
