EXTRA_OEMAKE:append = " CFG_DDR_SIZE=0x200000000 "
