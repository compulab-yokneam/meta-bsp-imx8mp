FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-Not-enough-parameters-passed-to-SWIG_Python_Appe.patch"

